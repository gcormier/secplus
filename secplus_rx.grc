options:
  parameters:
    generate_options: qt_gui
    id: secplus_rx
    output_language: python
  states: {}

blocks:
- name: decim1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '100'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Frequency
    label0: 315 MHz
    label1: 390 MHz
    num_opts: '2'
    option1: '390150000'
    orient: Qt.QHBoxLayout
    type: int
    value: '315150000'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * -300e3 / samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: '6'
    lna_path_ch0: '1'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
    serial: 1D4C29E4AA7E8D
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: 100000 // decim1 // decim2
    srate: samp_rate // decim1 // decim2
    tr_level: threshold
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim1
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim2
    interp: '1'
    taps: '[1.0/decim2]*decim2'
    type: fff
  states: {}
- name: secplus_decode
  id: epy_block
  parameters:
    _source_code: |
      #
      # Copyright 2016 Clayton Smith (argilo@gmail.com)
      #
      # This file is part of secplus.
      #
      # secplus is free software: you can redistribute it and/or modify
      # it under the terms of the GNU General Public License as published by
      # the Free Software Foundation, either version 3 of the License, or
      # (at your option) any later version.
      #
      # secplus is distributed in the hope that it will be useful,
      # but WITHOUT ANY WARRANTY; without even the implied warranty of
      # MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
      # GNU General Public License for more details.
      #
      # You should have received a copy of the GNU General Public License
      # along with secplus.  If not, see <http://www.gnu.org/licenses/>.
      #

      from __future__ import print_function
      import numpy as np
      from gnuradio import gr
      import secplus


      class blk(gr.sync_block):
          """Decoder for Chamberlain garage door openers"""

          def __init__(self, samp_rate=10000, threshold=0.02):
              gr.sync_block.__init__(
                  self,
                  name='Security+ Decoder',

                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.samp_rate = samp_rate
              self.threshold = threshold
              self.last_sample = 0.0
              self.last_rise = 0
              self.buffer = []
              self.last_pair = []
              self.pair = []

          def work(self, input_items, output_items):
              for n, sample in enumerate(input_items[0]):
                  current_sample = self.nitems_read(0) + n
                  if self.last_sample < self.threshold <= sample:
                      # rising edge
                      self.last_rise = current_sample
                  elif self.last_sample >= self.threshold > sample:
                      # falling edge
                      on_samples = current_sample - self.last_rise
                      self.process_symbol(on_samples)
                  if current_sample - self.last_rise > 3.25e-3 * self.samp_rate:
                      self.buffer = []
                  self.last_sample = sample
              return len(input_items[0])

          def process_symbol(self, on_samples):
              if on_samples < 0.35e-3 * self.samp_rate:
                  self.buffer = []
              elif on_samples < 0.75e-3 * self.samp_rate:
                  self.buffer.append(0)
              elif on_samples < 1.25e-3 * self.samp_rate:
                  self.buffer.append(1)
              elif on_samples < 1.75e-3 * self.samp_rate:
                  self.buffer.append(2)
              else:
                  self.buffer = []

              if len(self.buffer) == 21:
                  self.process_buffer()
                  self.buffer = []

          def process_buffer(self):
              if self.buffer[0] == 0:
                  self.pair = self.buffer[1:21]
              elif len(self.pair) == 20 and self.buffer[0] == 2:
                  self.pair += self.buffer[1:21]

              if len(self.pair) == 40 and self.pair != self.last_pair:
                  rolling, fixed = secplus.decode(self.pair)
                  print(secplus.pretty(rolling, fixed))
                  self.last_pair = self.pair
    samp_rate: samp_rate // decim1 // decim2
    threshold: threshold
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_1, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_0, '0']
- [limesdr_source_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', secplus_decode, '0']

metadata:
  file_format: 1
